# Keil uVision project mk70f15.uvprojx, settings and files
target mk70f15 (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(150000000) ELITTLE
  output: mk70f15
  c flags: Optim=1 wLevel=2
  c include: C:\Keil_V503\ARM\PACK\ARM\CMSIS\3.20.4\CMSIS\Driver\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\5.1.4\FileSystem\Include\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group sources
    ./: adc.c main.c Diagnostics.c FileSystem.c rtc.c timers.c
  group lib
    ./math/: math.lib
  group nand
    ./nand/: NAND_Flash.c NAND_MK70.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil_V503/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    C:/Keil_V503/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM4.lib
  group ::Device
    RTE/Device/MK70FN1M0xxx15/: startup_MK70F15.s system_MK70F15.c
  group ::File System
    RTE/File_System/: FS_Config_MC_0.h
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, CMSIS:RTOS:Keil RTX 4.74.0, File System:Drive:Memory Card 5.0.4, Device:Startup 1.0.0
