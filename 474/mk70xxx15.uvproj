# Keil uVision project mk70xxx15.uvproj, settings and files
target mk70xxx15 (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: mk70xxx15 +hex
  c flags: Optim=1 wLevel=2
  c define: STDIO __DEBUG __UTF8
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group startup
    ./startup/: startup_MK70F15.s system_MK70F15.c
  group config
    ./config/: RTX_Conf_CM.c File_Config.c
  group adc
    ./source/adc/: adc.c
  group diagnostics
    ./source/diagnostics/: Diagnostics.c
  group file_system
    ./source/file_system/: file_system.c NAND_MK70.c
  group rtc
    ./source/rtc/: rtc.c
  group serial
    ./source/serial/: getline.c SER.c
  group lib
    ./source/math/obj/: math.lib
    C:/Keil/ARM/RV31/LIB/: FS_CM3.lib
  group main
    ./source/: main.c Retarget.c
  group log
    ./source/log/: log.c
  group system
    ./source/system/: system.c
  group spi
    ./source/spi/: relay.c led.c spi.c keyboard.c
  group lcd
    ./source/lcd/: lcd.c
