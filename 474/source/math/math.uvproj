# Keil uVision project math.uvproj, settings and files
target MK70FN1M (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: math (library)
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group main
    ./: Alg2x.c
  group startup
    ../../startup/: startup_MK70F15.s system_MK70F15.c
  group source
    ./: Complex.c errHelper.c FIFO.c FreqAlg.c Logic.c MeasAlgs.c
  group lib
    C:/Keil/ARM/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
