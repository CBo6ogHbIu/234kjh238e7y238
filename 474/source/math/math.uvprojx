# Keil uVision project math.uvprojx, settings and files
target math (ARM-ADS)
  device: MK70FN1M0xxx15 Freescale Semiconductor
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(150000000) ELITTLE
  output: math
  c flags: Optim=1 oTime=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group source
    ./: Alg2x.c Complex.c errHelper.c FIFO.c FreqAlg.c Logic.c MeasAlgs.c
  group ::CMSIS
    C:/Keil/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    RTE/Device/MK70FN1M0xxx15/: startup_MK70F15.s system_MK70F15.c
software components: CMSIS:CORE 3.20.0, CMSIS:DSP 1.4.1, Device:Startup 1.0.0
